# Keil uVision project NN_ModelInference_SDS.uvprojx, settings and files
target Create Report (6190000::V6.19::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: SDS_Buffer_CMSIS
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: NVT_VECTOR_ON_FLASH, TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU, ACTIVATION_BUF_SZ=0x100000
  c include: ..\..\NN_ModelInference_SDS;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\NN_ModelInference_SDS\Device\include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\CMSIS\NN\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math;..\..\NN_ModelInference_SDS\Model\include;..\..\NN_ModelInference_SDS\NPU\include;..\..\NN_ModelInference_SDS\ProfilerCounter\include;..\..\..\..\Library\SDS-Framework\example\framework\interface\sensor\include;..\..\..\..\Library\SDS-Framework\example\framework\layer\Board\M55M1\Driver;..\..\..\..\ThirdParty\MPU6500\example;..\..\..\..\ThirdParty\MPU6500\interface;..\..\..\..\ThirdParty\MPU6500\src
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT8: RAM 0x20300000 size 0x2000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group Source Files
    ../: main.cpp sds_app_config.h ModelFileReader.c BoardInit.cpp
    ../../../../Library/SDS-Framework/example/framework/interface/sensor/source/: sensor_drv.c
    ../../../../Library/SDS-Framework/example/framework/layer/Board/M55M1/Driver/: sensor_drv_hw.c
  group Device
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
    ../../../../Library/Storage/: diskio_SDH.c
    ../Device/HyperRAM/: hyperram_code.c
    ../Device/SDCard/: sdglue.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sdh.c spim_hyper.c sys.c uart.c lpi2c.c pdma.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group MPU6500_driver
    ../../../../ThirdParty/MPU6500/example/: driver_mpu6500_fifo.c
    ../../../../ThirdParty/MPU6500/interface/: m55m1_driver_mpu6500_interface.c
    ../../../../ThirdParty/MPU6500/src/: driver_mpu6500.c
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Model.cc TensorFlowLiteMicro.cc Classifier.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c ffunicode.c
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group Lib
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    ../../../../Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group Model
    ../Model/: NN_Model_INT8.tflite.cpp NNModel.cpp Labels.cpp
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, SDS:Buffer 1.0.0
