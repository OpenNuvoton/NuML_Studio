# Keil uVision project SDS_Player_fs_CMSIS.uvprojx, settings and files
target SDS_Player_fs_CMSIS (6190000::V6.19::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: SDS_Player_fs_CMSIS
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Driver\Source;..\..\..\..\Library\CMSIS\Driver\Source\Driver_USBH\Driver_USBH_EHCI\Include;..\..\..\..\Library\CMSIS\Driver\Source\Driver_USBH\Driver_USBH_OHCI\Include;..\..\..\..\Library\CMSIS\Core\Include
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  link misc: --pd="-DSTACK_SIZE=0x1000" --pd="-DHEAP_SIZE=0x4000"
  group Device
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group StdDriver
    ../../../../Library/StdDriver/src/: clk.c pdma.c sys.c uart.c
  group CMSIS Driver
    ../../../../Library/CMSIS/Driver/Source/RTE_Device/: RTE_Device.h
    ../../../../Library/CMSIS/Driver/Source/: retarget.c misc.c drv_pdma.c
    ../../../../Library/CMSIS/Driver/Source/Driver_USBH/Driver_USBH_EHCI/Source/: Driver_USBH_EHCI.c Driver_USBH_EHCI_HW.c
    ../../../../Library/CMSIS/Driver/Source/Driver_USBH/Driver_USBH_OHCI/Source/: Driver_USBH_OHCI.c Driver_USBH_OHCI_HW.c
  group User
    ../: main.c USBH_MSC.c sds_app_config.h
software components: CMSIS Driver:USB Host:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, SDS:Buffer 1.0.0, SDS:IO:File System 1.2.0, SDS:Player 2.0.0, File System:CORE 8.0.0, File System:Drive:USB 8.0.0, USB:CORE 8.0.0, USB:Host 8.0.0, USB:Host:MSC 8.0.0, CMSIS-Compiler:File Interface:MDK-MW File System 1.0.1
