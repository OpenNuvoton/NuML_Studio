# Keil uVision project SDS_Buffer_CMSIS.uvprojx, settings and files
target Create Report (6190000::V6.19::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: SDS_Buffer_CMSIS
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NVT_VECTOR_ON_FLASH
  c include: ..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\Driver\Include;..\..\..\..\Library\CMSIS\Driver\Source;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SDS-Framework\example\framework\interface\sensor\include;..\..\..\..\Library\SDS-Framework\example\framework\layer\Board\M55M1\Driver;..\..\..\..\ThirdParty\MPU6500\example;..\..\..\..\ThirdParty\MPU6500\interface;..\..\..\..\ThirdParty\MPU6500\src;..\..\..\..\Library\CMSIS\Core\Include
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT8: RAM 0x20300000 size 0x2000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group Source Files
    ../: main.c sds_app_config.h
    ../../../../Library/SDS-Framework/example/framework/interface/sensor/source/: sensor_drv.c
    ../../../../Library/SDS-Framework/example/framework/layer/Board/M55M1/Driver/: sensor_drv_hw.c
  group CMSIS Driver
    ../../../../Library/CMSIS/Driver/Source/: drv_pdma.c misc.c
    ../../../../Library/CMSIS/Driver/Source/Driver_USART/: Driver_USART_UART.c
  group Device
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group BSP Driver
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c pdma.c lpi2c.c
  group MPU6500_driver
    ../../../../ThirdParty/MPU6500/example/: driver_mpu6500_fifo.c
    ../../../../ThirdParty/MPU6500/interface/: m55m1_driver_mpu6500_interface.c
    ../../../../ThirdParty/MPU6500/src/: driver_mpu6500.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, SDS:Buffer 1.0.0
