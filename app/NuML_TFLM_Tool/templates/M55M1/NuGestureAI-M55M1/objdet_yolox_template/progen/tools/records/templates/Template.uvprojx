# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M55M1R2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x00150000) IRAM2(0x30100000,0x00150000) IROM(0x00100000,0x00200000) IROM2(0x10100000,0x00200000) XROM(0x0F100000,0x00002000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Template
  AfterMake: fromelf --bin ".\build\@L.axf" --output ".\build\@L.bin"
  AfterMake: fromelf --text -c ".\build\@L.axf" --output ".\build\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  memory RVCT1: ROM 0xf100000 size 0x2000
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
