# Keil uVision project ImgClassInference_EdgeImpulse.uvprojx, settings and files
target ImgClassInference_EdgeImpulse (6190000::V6.19::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: ImgClassInference_EdgeImpulse
  AfterMake: fromelf --bin ".\build\@L.axf" --output ".\build\@L.bin"
  AfterMake: fromelf --text -c ".\build\@L.axf" --output ".\build\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: NVT_VECTOR_ON_FLASH, TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU, ACTIVATION_BUF_SZ=0x100000, EI_PORTING_NVT_M55A1, EI_ETHOS, ETHOSU_ARCH=u55, ETHOSU55, EI_CLASSIFIER_ALLOCATION_STATIC
  c include: ..\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\Device\include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FatFs\source;..\NPU\include;..\ProfilerCounter\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\edgeimpulse_model;..\..\..\..\ThirdParty\edgeimpulse;..\..\..\..\ThirdParty\edgeimpulse\edge-impulse-sdk\porting\ethos-core-driver\include;..\..\..\..\ThirdParty\openmv\omv\Lib;..\..\..\..\ThirdParty\openmv\omv\common;..\..\..\..\ThirdParty\openmv\omv\imlib;..\..\..\..\ThirdParty\openmv\omv\alloc;..\..\..\..\ThirdParty\edgeimpulse\edge-impulse-sdk\CMSIS\DSP\Include
  asm misc: -DNVT_VECTOR_ON_FLASH -DTF_LITE_STATIC_MEMORY -DARM_MATH_DSP -DARM_NPU -DACTIVATION_BUF_SZ=0x100000
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\KEIL\armcc.scatter
  group Application
    ../: BoardInit.cpp main.cpp ModelFileReader.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Device
    ../../../../Library/Storage/: diskio_SDH.c
    ../Device/HyperRAM/: hyperram_code.c
    ../Device/SDCard/: sdglue.c
    ../Device/ImageSensor/: ImageSensor.c
    ../Device/ImageSensor/Sensor/: Sensor_HM1055.c SWI2C.c
    ../Device/UVC/: descriptors.c UVC.c
  group Driver
    ../../../../Library/StdDriver/src/: ccap.c clk.c gpio.c retarget.c sdh.c spim_hyper.c sys.c uart.c hsusbd.c pdma.c
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c ffunicode.c
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group default
    ../../../../Library/StdDriver/inc/: acmp.h awf.h bpwm.h canfd.h ccap.h clk.h crc.h crypto.h dac.h dmic.h eadc.h ebi.h ecap.h epwm.h eqei.h fmc.h gpio.h hsotg.h hsusbd.h i2c.h i2s.h i3c.h kdf.h kpi.h ks.h lpadc.h lpgpio.h lpi2c.h lppdma.h lpspi.h lptmr.h lptmr_pwm.h lpuart.h mpu_config_M55M1_template.h otfc.h otg.h partition_M55M1_template.h pdma.h pmc.h psio.h qspi.h rng.h rtc.h sc.h scuart.h sdh.h spi.h spim.h spim_hyper.h sys.h timer.h timer_pwm.h trng.h ttmr.h uart.h usbd.h usci_i2c.h usci_spi.h usci_uart.h utcpd.h wdt.h wwdt.h
    ../../../../Library/Device/Nuvoton/M55M1/Include/: acmp_reg.h awf_reg.h bpwm_reg.h canfd_reg.h ccap_reg.h clk_reg.h crc_reg.h crypto_reg.h dac_reg.h dmic_reg.h eadc_reg.h ebi_reg.h ecap_reg.h epwm_reg.h eqei_reg.h fmc_reg.h gpio_reg.h hsotg_reg.h hsusbd_reg.h hsusbh_reg.h i2c_reg.h i2s_reg.h i3c_reg.h kdf_reg.h kpi_reg.h ks_reg.h lpadc_reg.h lpgpio_reg.h lpi2c_reg.h lppdma_reg.h lpspi_reg.h lptmr_reg.h lpuart_reg.h M55M1.h NuMicro.h otfc_reg.h otg_reg.h pdma_reg.h pmc_reg.h psio_reg.h qspi_reg.h rtc_reg.h sc_reg.h scu_reg.h sdh_reg.h spi_reg.h spim_reg.h sys_reg.h system_M55M1.h timer_reg.h trng_reg.h ttmr_reg.h uart_reg.h ui2c_reg.h usbd_reg.h usbh_reg.h uspi_reg.h utcpd_reg.h uuart_reg.h wdt_reg.h wwdt_reg.h
    ../../../../Library/CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
    ../../../../Library/CMSIS/NN/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
    ../../../../Library/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    ../../../../ThirdParty/FatFs/source/: diskio.h ff.h ffconf.h integer.h
    ../../../../Library/StdDriver/inc/npu/: ethosu_driver.h ethosu_types.h pmu_ethosu.h
    ../../NN_ModelInference/NPU/include/: ethosu_mem_config.h ethosu_npu_init.h ethosu_profiler.h
    ../../NN_ModelInference/: ffconf_M55M1.h ModelFileReader.h mpu_config_M55M1.h
    ../../NN_ModelInference/Device/include/: hyperram_code.h
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/log/include/: log_macros.h
    ../../NN_ModelInference/ProfilerCounter/include/: pmu_counter.h
  group edge-impulse-porting
    ../../../../ThirdParty/edgeimpulse/edge-impulse-sdk/porting/nvt-M55M1/: debug_log.cpp ei_classifier_porting.cpp
  group edge-impulse-sdk
    ../../../../ThirdParty/edgeimpulse/edge-impulse-sdk/classifier/: ei_run_classifier_c.cpp
    ../../../../ThirdParty/edgeimpulse/edge-impulse-sdk/dsp/: memory.cpp
    ../../../../ThirdParty/edgeimpulse/edge-impulse-sdk/dsp/dct/: fast-dct-fft.cpp
    ../../../../ThirdParty/edgeimpulse/edge-impulse-sdk/dsp/image/: processing.cpp
    ../../../../ThirdParty/edgeimpulse/edge-impulse-sdk/dsp/kissfft/: kiss_fft.cpp kiss_fftr.cpp
  group tflite-model
    ../edgeimpulse_model/tflite-model/: tflite_learn_774988_3_compiled.cpp
  group edge-impulse-ethosu
    ../../../../ThirdParty/edgeimpulse/edge-impulse-sdk/porting/ethos-core-driver/src/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group edge-impulse-lib
    ../../../../ThirdParty/edgeimpulse/Lib/: tflu.lib
    ../../../../ThirdParty/edgeimpulse/Lib/CMSIS/Lib/KEIL/: cmsis_nn.lib cmsis_dsp.lib
  group Lib
    ../../../../ThirdParty/openmv/omv/Lib/: omv.lib
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
